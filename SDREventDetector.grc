options:
  parameters:
    author: JoeTester1965
    copyright: MIT License
    generate_options: qt_gui
    id: SDREventDetector
    output_language: python
    run_options: run
    title: SDREventDetector-grc
  states: {}

blocks:
- name: center_freq_default
  id: variable
  parameters:
    value: '434000000'
  states: {}
- name: fft_frame_rate_default
  id: variable
  parameters:
    value: '20'
  states: {}
- name: fft_resolution_default
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: gain_default
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate_default
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test-recording
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test-recording
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_default
    type: complex
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '1.0'
    fft_size: fft_resolution_default
    frame_rate: fft_frame_rate_default
    ref_scale: '1'
    sample_rate: samp_rate_default
    shift: 'True'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: see zmqpubsink.py
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: see zmqpubsink.py
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: 'enable if needed '
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: enable if needed
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    note: enable if needed
  states: {}
- name: note_0_1_0_0_0
  id: note
  parameters:
    note: QT GUI as needed
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    ref_level: '-80'
    update_time: '0.05'
    vlen: fft_resolution_default
    x_start: '0'
    x_step: '1.0'
    ymax: '-0'
    ymin: '-80'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq_default
    gain: gain_default
    samp_rate: samp_rate_default
    type: fc32
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:50242
    timeout: '100'
    type: float
    vlen: fft_resolution_default
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50241
    timeout: '100'
  states: {state: disabled}

connections:
- [blocks_correctiq_0, '0', blocks_file_sink_0, '0']
- [blocks_correctiq_0, '0', logpwrfft_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', logpwrfft_x_0, '0']
- [logpwrfft_x_0, '0', qtgui_vector_sink_f_0, '0']
- [logpwrfft_x_0, '0', zeromq_pub_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_correctiq_0, '0']
- [zeromq_pull_msg_source_0, out, soapy_rtlsdr_source_0, cmd]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
