options:
  parameters:
    author: JoeTester1965
    copyright: MIT License
    generate_options: no_gui
    id: SDREventDetector
    output_language: python
    run_options: run
    title: SDREventDetector-grc
  states: {}

blocks:
- name: center_freq
  id: variable_config
  parameters:
    config_file: SDREventDetector.ini
    option: center_freq
    section: grc
    type: int
    value: '434000000'
    writeback: None
  states: {}
- name: fft_frame_rate
  id: variable_config
  parameters:
    config_file: SDREventDetector.ini
    option: fft_frame_rate
    section: grc
    type: int
    value: '1024'
    writeback: None
  states: {}
- name: fft_resolution
  id: variable_config
  parameters:
    config_file: SDREventDetector.ini
    option: fft_resolution
    section: grc
    type: int
    value: '20'
    writeback: None
  states: {}
- name: gain
  id: variable_config
  parameters:
    config_file: SDREventDetector.ini
    option: gain
    section: grc
    type: int
    value: '10'
    writeback: None
  states: {}
- name: sample_rate
  id: variable_config
  parameters:
    config_file: SDREventDetector.ini
    option: sample_rate
    section: grc
    type: int
    value: '2048000'
    writeback: None
  states: {}
- name: xml_rpc_port
  id: variable_config
  parameters:
    config_file: SDREventDetector.ini
    option: xml_rpc_port
    section: rpc-network-config
    type: int
    value: '50249'
    writeback: None
  states: {}
- name: xml_rpc_server
  id: variable_config
  parameters:
    config_file: SDREventDetector.ini
    option: xml_rpc_server
    section: rpc-network-config
    type: string
    value: '"127.0.0.1"'
    writeback: None
  states: {}
- name: zmq_network_config
  id: variable_config
  parameters:
    config_file: SDREventDetector.ini
    option: zmq_address
    section: zmq-network-config
    type: string
    value: tcp://127.0.0.1:50242
    writeback: None
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '1.0'
    fft_size: fft_resolution
    frame_rate: fft_frame_rate
    ref_scale: '1'
    sample_rate: sample_rate
    shift: 'True'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    gain: gain
    samp_rate: sample_rate
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: xml_rpc_server
    port: xml_rpc_port
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_network_config
    timeout: '100'
    type: float
    vlen: fft_resolution
  states: {}

connections:
- [blocks_correctiq_0, '0', logpwrfft_x_0, '0']
- [logpwrfft_x_0, '0', zeromq_pub_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
